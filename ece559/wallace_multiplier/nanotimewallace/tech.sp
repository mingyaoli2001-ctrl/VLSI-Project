*nanosim tech="direct"
*nanosim tech="voltage 1.0"
*nanosim tech="vds 0 1.0 0.05" *nanosim tech="vgs 0 1.0 0.05"
.include "/package/eda/cells/FreePDK45/models/hspice/tran_models/models_nom/NMOS_VTL.inc"
.include "/package/eda/cells/FreePDK45/models/hspice/tran_models/models_nom/PMOS_VTL.inc"
